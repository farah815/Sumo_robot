Commit message: Update robot.urdf

File: urdf/robot.urdf (robot description, URDF)
Before this commit: robot sumo_robot, 11 links, 10 joints
Links:
- link body: mass 10.26 -> 2
Joints:
- joint lidar_joint: origin xyz=0.000210 0.20 -0.174 rpy=0 0 0 -> xyz=0.000210 0.20 -0.174 rpy=1.5708 0 0
